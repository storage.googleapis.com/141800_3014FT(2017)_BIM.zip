Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2018-06-20T11:07:54
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.2.0.0 - Alternate UI 16.2.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jun 20 11:07:54 2018 * Host: pcz-computer * Database: C:\Users\Paloma\AppData\Local\Temp\{1ACE22B6-5E9F-45CD-972F-9229FC04EF97}\ifc * Database version: 5507 * Database creation date: Wed Jun 20 11:07:53 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jun 20 11:07:54 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jun 20 11:07:54 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Circle Head - Project Datum; Family and Type: Level: Circle Head - Project Datum; Type: Level: Circle Head - Project Datum; Type Id: Level: Circle Head - Project Datum
Identity Data - Type Name: Circle Head - Project Datum; Building Story: yes; Name: Level 0; Structural: no
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Graphics - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: Anno_Level_Head_Circle: Standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: no

# IfcFlowController: 3014FT Washbasin faucet, 9/12 V, 3014FT(2017):3014FT Washbasin faucet, 9/12 V:365214
In: Level 0
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 142.5 mm; NominalHeight: 138.5 mm; NominalWidth: 50 mm; Projection: 100 mm
Type - Electrical - Electrical Connection: 9 / 12 VDC; Operating Voltage: 12 V
Type - General - Author: Convergo AB; BIMObjectName: 3014FT; ConvergoRefNr: 0087-1806-0106-FI; ExpiringDate: 12/2018; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 19/06/2018
Type - Green Building Properties - EAN Number: 6414150082474; EMC Directive: 2014/30/EU; EN Standard: EN 15091; LVI Number: 6110232; Noise Class: I (ISO 3822); Protection Class: IP 55; RSK Number: 8430546; VVS Number: 704206404
Type - Identity Data - Class: Touchless, separate transformer; Group: Washbasin faucets; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;POL;RUS;EST;LTU;LVA;UKR; Model: 3014FT Washbasin faucet, 9/12 V; Name_en: 3014FT Washbasin faucet, 9/12 V; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 3014FT; Product Family: Oras Inspera; Type Name: 3014FT Washbasin faucet, 9/12 V
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Flow Rate At 300kPa With Flow Controller: 0.000706293 m3/s; Installation Type: Deck mounted; Intelligent After Flow Period: 2 s ± 1 s; Max. Hot Water Supply: 70 kg/K/s3; Max Flow Period: 120; Recognition Range: optimally preset
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 3014FT(2017); Features: Touchless, separate transformer; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 3014FT; Name: 3014FT Washbasin faucet, 9/12 V; ReplacementCost: n/a; Shape: Sculptured; Size: 50x143x140 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 3014FT; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 3014FT Washbasin faucet, 9/12 V
Constraints - DefaultElevation: 900 mm; Host: Level : Level 0; Level: Level: Level 0; Offset: 0 mm
Dimensions - Area: 0.0348858 m2; Volume: 0.000991525 m3
Identity Data - Mark: 31
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 3014FT(2017): 3014FT Washbasin faucet, 9/12 V; Family and Type: 3014FT(2017): 3014FT Washbasin faucet, 9/12 V; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 3014FT(2017): 3014FT Washbasin faucet, 9/12 V; Type Id: 3014FT(2017): 3014FT Washbasin faucet, 9/12 V; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
